# Keil uVision project STM32_ucgui.uvproj, settings and files
target uCOSII+STM32_V3_4 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: uCOSII+STM32_V3_4 +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,SYSCLK_FREQ_72MHz
  c include: ..\APP;..\BSP;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Core\CM3;..\Startup;..\uCOS-II\Source\;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\uCOS-II\Ports;..\uCGUIConfig;..\uCGUI\emWinDemo;..\GUIinc;..\TFT;..\uCGUI\uCGUIDemo;..\Device\;..\APP\nand_fatfs\inc\;..\FatFS\src\;..\Device\Nand\;..\USBLIB\inc\;..\inc;..\APP\UsbFiles\;..\Libraries\STM32F10x_StdPeriph_Driver\inc\;..\Libraries\;..\Libraries\STM32F10x_StdPeriph_Driver\inc;.\USBLIB\inc\;.\USBLIB\inc\;..\inc\;..\inc\;..\inc\;.\UsbFiles\;..\UsbFiles\;.\HD7279A_interface;.\24CXX;.\IIC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./: app.c stm32f10x_it.c SysTick.c lcd.c motodrive.c time.c gps.c check.c pps.c queue.c mp3.c
    ../Device/: SD_driver.c
  group BSP
    ../BSP/: bsp.c
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uC-OS-II/Port
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Device
    ../Device/: USART1.c USART2.c
    ./HD7279A_interface/: HD7279.c
    ./: ds3231.c iic_sw.c uart.c key.c
    ./24CXX/: 24cxx.c
    ./IIC/: myiic.c
  group FatFs
    ../FatFS/src/: ff.c diskio.c
    ../FatFS/src/option/: cc936.c
  group Documentation
    ../: 读我.txt
    ../Doc/: 01.例程功能说明.txt
  group MDK_ARM
    ../Startup/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
    ../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c
target RAM (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32
  c flags: Optim=2 oTime=1 OneElfS=1 wLevel=2
  c define: "VECT_TAB_RAM"
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x2000
  scatter file: ..\BSP\STM32_Flash.scat
  link misc: --entry ResetHndlr
